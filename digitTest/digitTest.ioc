# file: digitTest.ioc
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Mcu.Family=STM32G4
Mcu.Name=STM32G474R(B-C-E)Tx
Mcu.Package=LQFP64
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
ProjectManager.HeapSize=0x800
ProjectManager.StackSize=0x800
ProjectManager.TargetToolchain=Makefile
RCC.ADC12Freq_Value=170000000
RCC.ADC345Freq_Value=170000000
RCC.AHBFreq_Value=170000000
RCC.APB1Freq_Value=170000000
RCC.APB1TimFreq_Value=170000000
RCC.APB2Freq_Value=170000000
RCC.APB2TimFreq_Value=170000000
RCC.CortexFreq_Value=170000000
RCC.EXTERNAL_CLOCK_VALUE=12288000
RCC.HCLKFreq_Value=170000000
RCC.HSE_VALUE=8000000
RCC.HSI48_VALUE=48000000
RCC.HSI_VALUE=16000000
RCC.LSE_VALUE=32768
RCC.PLLM=RCC_PLLM_DIV4
RCC.PLLN=85
RCC.SYSCLKFreq_VALUE=170000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
RCC.USBFreq_Value=170000000
RCC.VCOOutputFreq_Value=340000000
STMicroelectronics.X-CUBE-AI.7.0.0.ActivationBufferSizeList=33000
STMicroelectronics.X-CUBE-AI.7.0.0.ApplicationCcDeviceJjApplication=ApplicationTemplate
STMicroelectronics.X-CUBE-AI.7.0.0.HeapSize=0x800
STMicroelectronics.X-CUBE-AI.7.0.0.InternalRamActivationBufferMaxSize=AI_NETWORK_DATA_ACTIVATIONS_SIZE
STMicroelectronics.X-CUBE-AI.7.0.0.LatestDirectoryUsed-efaad758654f30c4442f634998ed06021e92ff002bf7ab89e838ca64f23c19c1=/home/harshd
STMicroelectronics.X-CUBE-AI.7.0.0.MaximumNumberOfInputLayer=1
STMicroelectronics.X-CUBE-AI.7.0.0.MaximumNumberOfOutputLayer=1
STMicroelectronics.X-CUBE-AI.7.0.0.MaximumSizeOfInputLayer=AI_NETWORK_IN_1_SIZE_BYTES
STMicroelectronics.X-CUBE-AI.7.0.0.MaximumSizeOfOutputLayer=AI_NETWORK_OUT_1_SIZE_BYTES
STMicroelectronics.X-CUBE-AI.7.0.0.ModelActualCompression-efaad758654f30c4442f634998ed06021e92ff002bf7ab89e838ca64f23c19c1=4.9097614
STMicroelectronics.X-CUBE-AI.7.0.0.ModelCompression-efaad758654f30c4442f634998ed06021e92ff002bf7ab89e838ca64f23c19c1=8
STMicroelectronics.X-CUBE-AI.7.0.0.ModelFlashOccupation-efaad758654f30c4442f634998ed06021e92ff002bf7ab89e838ca64f23c19c1=183400
STMicroelectronics.X-CUBE-AI.7.0.0.ModelHashList=efaad758654f30c4442f634998ed06021e92ff002bf7ab89e838ca64f23c19c1
STMicroelectronics.X-CUBE-AI.7.0.0.ModelKind-efaad758654f30c4442f634998ed06021e92ff002bf7ab89e838ca64f23c19c1=KERAS
STMicroelectronics.X-CUBE-AI.7.0.0.ModelMacc-efaad758654f30c4442f634998ed06021e92ff002bf7ab89e838ca64f23c19c1=2688960
STMicroelectronics.X-CUBE-AI.7.0.0.ModelName-efaad758654f30c4442f634998ed06021e92ff002bf7ab89e838ca64f23c19c1=network
STMicroelectronics.X-CUBE-AI.7.0.0.ModelNameList=network
STMicroelectronics.X-CUBE-AI.7.0.0.ModelRamOccupation-efaad758654f30c4442f634998ed06021e92ff002bf7ab89e838ca64f23c19c1=33000
STMicroelectronics.X-CUBE-AI.7.0.0.ModelStructureFile-efaad758654f30c4442f634998ed06021e92ff002bf7ab89e838ca64f23c19c1=/home/harshd/digitRcgSTM32.h5
STMicroelectronics.X-CUBE-AI.7.0.0.ModelType-efaad758654f30c4442f634998ed06021e92ff002bf7ab89e838ca64f23c19c1=Saved model
STMicroelectronics.X-CUBE-AI.7.0.0.ReadyForCodeGeneration=true
STMicroelectronics.X-CUBE-AI.7.0.0.StackSize=0x800
STMicroelectronics.X-CUBE-AI.7.0.0.WorkingBufferStartAddrList=0xFFFFFFFF
STMicroelectronics.X-CUBE-AI.7.0.0.XAaCUBEAaAICcArtificialOoIntelligenceJjCore=true
VP_CRC_VS_CRC.Mode=CRC_Activate
VP_STMicroelectronics.X-CUBE-AI_VS_ArtificialOoIntelligenceJjXAaCUBEAaAI_7.0.0.Mode=ArtificialOoIntelligenceJjXAaCUBEAaAI
VP_STMicroelectronics.X-CUBE-AI_VS_DeviceJjApplication_7.0.0.Mode=DeviceJjApplication
VP_SYS_VS_DBSignals.Mode=DisableDeadBatterySignals
board=custom

// file: Core/Src/main.c
/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.c
  * @brief          : Main program body
  ******************************************************************************
  * @attention
  *
  * <h2><center>&copy; Copyright (c) 2021 STMicroelectronics.
  * All rights reserved.</center></h2>
  *
  * This software component is licensed by ST under Ultimate Liberty license
  * SLA0044, the "License"; You may not use this file except in compliance with
  * the License. You may obtain a copy of the License at:
  *                             www.st.com/SLA0044
  *
  ******************************************************************************
  */
/* USER CODE END Header */
#include "main.h"
#include "app_x-cube-ai.h"

#define DVFS_SETTING_3

#ifdef DVFS_SETTING_1
#define PLLM_VAL RCC_PLLM_DIV8
#define PLLN_VAL 8
#define FLASH_WAITS FLASH_LATENCY_0
#define REG_VOLTAGE PWR_REGULATOR_VOLTAGE_SCALE2

#elif defined(DVFS_SETTING_2)
#define PLLM_VAL RCC_PLLM_DIV8
#define PLLN_VAL 16
#define FLASH_WAITS FLASH_LATENCY_1
#define REG_VOLTAGE PWR_REGULATOR_VOLTAGE_SCALE2

#elif defined(DVFS_SETTING_3)
#define PLLM_VAL RCC_PLLM_DIV8
#define PLLN_VAL 24
#define FLASH_WAITS FLASH_LATENCY_1
#define REG_VOLTAGE PWR_REGULATOR_VOLTAGE_SCALE2

#elif defined(DVFS_SETTING_4)
#define PLLM_VAL RCC_PLLM_DIV8
#define PLLN_VAL 48
#define FLASH_WAITS FLASH_LATENCY_1
#define REG_VOLTAGE PWR_REGULATOR_VOLTAGE_SCALE1

#elif defined(DVFS_SETTING_5)
#define PLLM_VAL RCC_PLLM_DIV8
#define PLLN_VAL 64
#define FLASH_WAITS FLASH_LATENCY_2
#define REG_VOLTAGE PWR_REGULATOR_VOLTAGE_SCALE1

#elif defined(DVFS_SETTING_6)
#define PLLM_VAL RCC_PLLM_DIV4
#define PLLN_VAL 75
#define FLASH_WAITS FLASH_LATENCY_4
#define REG_VOLTAGE PWR_REGULATOR_VOLTAGE_SCALE1

#elif defined(DVFS_SETTING_7)
#define PLLM_VAL RCC_PLLM_DIV4
#define PLLN_VAL 85
#define FLASH_WAITS FLASH_LATENCY_4
#define REG_VOLTAGE PWR_REGULATOR_VOLTAGE_SCALE1_BOOST

#endif

CRC_HandleTypeDef hcrc;

void SystemClock_Config(void);
void SystemClock_Decrease(void);

static void MX_CRC_Init(void);

/* USER CODE BEGIN 0 */
static GPIO_InitTypeDef  GPIO_InitStruct;

/* USER CODE END 0 */

int main(void)
{

  /* MCU Configuration--------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  HAL_Init();

  /* Configure the system clock */
  SystemClock_Config();

	__HAL_RCC_GPIOA_CLK_ENABLE();
  GPIO_InitStruct.Pin = GPIO_PIN_8;
	GPIO_InitStruct.Mode = GPIO_MODE_IT_RISING;
	GPIO_InitStruct.Pull = GPIO_NOPULL;
	HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);

	HAL_NVIC_SetPriority(EXTI9_5_IRQn, 2, 0);
 	HAL_NVIC_EnableIRQ(EXTI9_5_IRQn);

	SystemClock_Decrease();
	HAL_SuspendTick();

	// Enter Sleep Mode, wake up is done once User push-button is pressed *
	HAL_PWR_EnterSLEEPMode(PWR_LOWPOWERREGULATOR_ON, PWR_SLEEPENTRY_WFI);

	HAL_PWREx_DisableLowPowerRunMode();

  // Let's do this again
  HAL_Init();

	__HAL_RCC_GPIOA_CLK_ENABLE();

  /* USER CODE BEGIN Init */
  SystemClock_Config();

  /* USER CODE BEGIN SysInit */
	__HAL_RCC_GPIOA_CLK_ENABLE();
	GPIO_InitStruct.Pin = GPIO_PIN_8;
	GPIO_InitStruct.Mode  = GPIO_MODE_OUTPUT_PP;
	GPIO_InitStruct.Pull  = GPIO_PULLUP;
	GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_HIGH;
  	HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);
 	//HAL_RCC_MCOConfig(RCC_MCO1, RCC_MCO1SOURCE_SYSCLK, RCC_MCODIV_1);

	GPIO_InitStruct.Pin = GPIO_PIN_9;
	GPIO_InitStruct.Mode  = GPIO_MODE_OUTPUT_PP;
	GPIO_InitStruct.Pull  = GPIO_PULLUP;
	GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_HIGH;
  	HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);

  /* USER CODE END SysInit */

  /* Initialize all configured peripherals */
	HAL_GPIO_WritePin(GPIOA, GPIO_PIN_9, GPIO_PIN_SET);
  MX_CRC_Init();
  MX_X_CUBE_AI_Init();
  /* USER CODE BEGIN 2 */
	//HAL_GPIO_WritePin(GPIOA, GPIO_PIN_9, GPIO_PIN_SET);
  MX_X_CUBE_AI_Process();
	HAL_GPIO_WritePin(GPIOA, GPIO_PIN_9, GPIO_PIN_RESET);

  /* USER CODE END 2 */

  /* Infinite loop */
  while (1)
  {

  }
}

void SystemClock_Config(void)
{
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

  /** Configure the main internal regulator output voltage
  */
  // HAL_PWREx_ControlVoltageScaling(PWR_REGULATOR_VOLTAGE_SCALE1_BOOST);
  // HAL_PWREx_ControlVoltageScaling(PWR_REGULATOR_VOLTAGE_SCALE1);
  // HAL_PWREx_ControlVoltageScaling(PWR_REGULATOR_VOLTAGE_SCALE2);
  HAL_PWREx_ControlVoltageScaling(REG_VOLTAGE);

  /** Initializes the RCC Oscillators according to the specified parameters
  * in the RCC_OscInitTypeDef structure.
  */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSI;
  RCC_OscInitStruct.HSIState = RCC_HSI_ON;
  RCC_OscInitStruct.HSICalibrationValue = RCC_HSICALIBRATION_DEFAULT;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
  RCC_OscInitStruct.PLL.PLLSource = RCC_PLLSOURCE_HSI; 		// HSI is set to 16MHz
  RCC_OscInitStruct.PLL.PLLM = PLLM_VAL; 				// PLLM sets VCO input to 2MHz
  RCC_OscInitStruct.PLL.PLLN = PLLN_VAL; 							// VCO output = 4MHz (VCO input) * PLLN; PLLN = main sys * 2 / 4MHz
  RCC_OscInitStruct.PLL.PLLP = RCC_PLLP_DIV2;
  RCC_OscInitStruct.PLL.PLLQ = RCC_PLLQ_DIV2;
  RCC_OscInitStruct.PLL.PLLR = RCC_PLLR_DIV2; 				// Main system clock = VCO output/2
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    Error_Handler();
  }
  /** Initializes the CPU, AHB and APB buses clocks
  */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV1;
  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_WAITS) != HAL_OK)
  {
    Error_Handler();
  }
}

void SystemClock_Decrease(void)
{
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};

  /* Select HSI as system clock source */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_SYSCLK;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_HSI;
  if(HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_0) != HAL_OK)
  {
    /* Initialization Error */
    Error_Handler();
  }

  /* Modify HSI to HSI DIV8 */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSI;
  RCC_OscInitStruct.HSIState = RCC_HSI_ON;
  RCC_OscInitStruct.HSICalibrationValue = RCC_HSICALIBRATION_DEFAULT;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_NONE;
  if(HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    /* Initialization Error */
    Error_Handler();
  }
}

static void MX_CRC_Init(void)
{

  hcrc.Instance = CRC;
  hcrc.Init.DefaultPolynomialUse = DEFAULT_POLYNOMIAL_ENABLE;
  hcrc.Init.DefaultInitValueUse = DEFAULT_INIT_VALUE_ENABLE;
  hcrc.Init.InputDataInversionMode = CRC_INPUTDATA_INVERSION_NONE;
  hcrc.Init.OutputDataInversionMode = CRC_OUTPUTDATA_INVERSION_DISABLE;
  hcrc.InputDataFormat = CRC_INPUTDATA_FORMAT_BYTES;
  if (HAL_CRC_Init(&hcrc) != HAL_OK)
  {
    Error_Handler();
  }

}

void Error_Handler(void)
{
  __disable_irq();
  while (1)
  {
  }
}

/************************ (C) COPYRIGHT STMicroelectronics *****END OF FILE****/
